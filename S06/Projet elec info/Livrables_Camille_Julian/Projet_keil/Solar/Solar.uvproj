# Keil uVision project Solar.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Solar
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group inc
    ./inc/: bsp.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h delay.h main.h mpu_armv7.h mpu_armv8.h stm32f0xx.h stm32f0xx_it.h stm32f072xb.h system_stm32f0xx.h tz_context.h
  group src
    ./src/: bsp.c delay.c main.c printf-stdarg.c stm32f0xx_it.c system_stm32f0xx.c
    ./: startup_stm32f072.s
